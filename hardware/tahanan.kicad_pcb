# Repository maglambayan/tahanan (continued)

## KiCad design hardware/tahanan.kicad_pcb (continued)

Board: 4 copper layers, 230 parts (6 on the bottom side), 155 nets, no tracks yet.

File manufacturing/bom/tahanan-pcba-bom.csv (part):

References,Qty,Value,Description,Manufacturer,MPN,Footprint,Fit,Alternates,Unit USD,Ext USD,Price basis,DigiKey stock,Supply note,DigiKey search,Mouser search,LCSC search,Datasheet
BT1,1,CR1220,"Coin cell holder 12mm, RTC backup",Keystone,3000,BatteryHolder_Keystone_3000_1x12mm,fit,,0.550,0.55,estimate,,,https://www.digikey.com/en/products/result?keywords=3000,https://www.mouser.com/c/?q=3000,https://www.lcsc.com/search?q=3000,
C1 C2 C15 C25 C35 C45 C46 C53 C87 C88 C94 C95 C97,13,1uF 16V,MLCC 1uF 16V X5R 0402,Samsung,CL05A105KO5NNNC,C_0402_1005Metric,fit,,0.008,0.10,estimate,,,https://www.digikey.com/en/products/result?keywords=CL05A105KO5NNNC,https://www.mouser.com/c/?q=CL05A105KO5NNNC,https://www.lcsc.com/search?q=CL05A105KO5NNNC,
C3,1,4.7uF 50V,MLCC 4.7uF 50V X5R 0805,Samsung,CL21A475KBQNNNE,C_0805_2012Metric,fit,,0.008,0.01,estimate,,,https://www.digikey.com/en/products/result?keywords=CL21A475KBQNNNE,https://www.mouser.com/c/?q=CL21A475KBQNNNE,https://www.lcsc.com/search?q=CL21A475KBQNNNE,
C4 C6 C7,3,100nF 50V,MLCC 100nF 50V X7R 0603,Samsung,CL10B104KB8NNNC,C_0603_1608Metric,fit,,0.008,0.02,estimate,,,https://www.digikey.com/en/products/result?keywords=CL10B104KB8NNNC,https://www.mouser.com/c/?q=CL10B104KB8NNNC,https://www.lcsc.com/search?q=CL10B104KB8NNNC,
C5 C8 C9 C11 C12 C21 C22 C31 C32,9,10uF 50V,MLCC 10uF 50V X7R 1210,Samsung,CL32B106KBJNNNE,C_1210_3225Metric,fit,,0.160,1.44,estimate,,,https://www.digikey.com/en/products/result?keywords=CL32B106KBJNNNE,https://www.mouser.com/c/?q=CL32B106KBJNNNE,https://www.lcsc.com/search?q=CL32B106KBJNNNE,
C10,1,100uF 35V,Aluminium electrolytic 100uF 35V low-ESR,Panasonic,EEE-FT1V101AP,CP_Elec_6.3x7.7,fit,,0.235,0.23,"DigiKey 2026-11-11, break at 1000",17076,,https://www.digikey.com/en/products/result?keywords=EEE-FT1V101AP,https://www.mouser.com/c/?q=EEE-FT1V101AP,https://www.lcsc.com/search?q=EEE-FT1V101AP,
C13 C23 C33,3,220nF 50V,MLCC 220nF 50V X7R 0603,Samsung,CL10B224KB8NNNC,C_0603_1608Metric,fit,,0.036,0.11,"DigiKey 2026-11-11, break at 500",138733,,https://www.digikey.com/en/products/result?keywords=CL10B224KB8NNNC,https://www.mouser.com/c/?q=CL10B224KB8NNNC,https://www.lcsc.com/search?q=CL10B224KB8NNNC,
C14 C24 C34 C42 C51 C52 C57 C58 C60 C62 C64 C65 C66 C67 C68 C76 C80 C81 C83 C84 C85 C86 C91 C92 C93 C96,26,100nF 16V,MLCC 100nF 16V X7R 0402,Samsung,CL05B104KO5NNNC,C_0402_1005Metric,fit,,0.008,0.21,estimate,,,https://www.digikey.com/en/products/result?keywords=CL05B104KO5NNNC,https://www.mouser.com/c/?q=CL05B104KO5NNNC,https://www.lcsc.com/search?q=CL05B104KO5NNNC,
C16 C26 C36,3,22pF 50V,MLCC 22pF 50V C0G 0402,Samsung,CL05C220JB5NNNC,C_0402_1005Metric,fit,,0.008,0.02,estimate,,,https://www.digikey.com/en/products/result?keywords=CL05C220JB5NNNC,https://www.mouser.com/c/?q=CL05C220JB5NNNC,https://www.lcsc.com/search?q=CL05C220JB5NNNC,
C17 C18 C19 C20 C27 C28 C29 C30 C37 C38 C39 C40 C43 C44 C47 C48 C49 C50 C54 C55 C56 C90,22,22uF 10V,MLCC 22uF 10V X5R 0805,Samsung,CL21A226MPQNNNE,C_0805_2012Metric,fit,,0.050,1.10,estimate,,,https://www.digikey.com/en/products/result?keywords=CL21A226MPQNNNE,https://www.mouser.com/c/?q=CL21A226MPQNNNE,https://www.lcsc.com/search?q=CL21A226MPQNNNE,
C41 C59 C75 C79 C82 C89,6,10uF 10V,MLCC 10uF 10V X5R 0603,Samsung,CL10A106KP8NNNC,C_0603_1608Metric,fit,,0.008,0.05,estimate,,,https://www.digikey.com/en/products/result?keywords=CL10A106KP8NNNC,https://www.mouser.com/c/?q=CL10A106KP8NNNC,https://www.lcsc.com/search?q=CL10A106KP8NNNC,
C61 C63,2,150uF 6.3V,Polymer tantalum 150uF 6.3V 70mOhm,KEMET,T520B157M006ATE070,CP_EIA-3528-21_Kemet-B,fit,,1.380,2.76,"DigiKey 2026-11-11, list price, break not shown",not shown,,https://www.digikey.com/en/products/result?keywords=T520B157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,https://www.mouser.com/c/?q=T520B157M006ATE070,https://www.lcsc.com/search?q=T520B157M006ATE070,
C69,1,100nF 100V,MLCC 100nF 100V X7R 0805,Samsung,CL21B104KCFNNNE,C_0805_2012Metric,fit,,0.008,0.01,estimate,,,https://www.digikey.com/en/products/result?keywords=CL21B104KCFNNNE,https://www.mouser.com/c/?q=CL21B104KCFNNNE,https://www.lcsc.com/search?q=CL21B104KCFNNNE,
C70 C72,2,1000uF 16V,"Aluminium electrolytic 1000uF 16V, required by Ag5810",Panasonic,EEE-FT1C102AP,CP_Elec_10x10.5,fit,,0.580,1.16,"DigiKey 2026-11-11, break at 1000",9181,,https://www.digikey.com/en/products/result?keywords=EEE-FT1C102AP,https://www.mouser.com/c/?q=EEE-FT1C102AP,https://www.lcsc.com/search?q=EEE-FT1C102AP,
C71 C73,2,10uF 25V,MLCC 10uF 25V X7R 1206,Samsung,CL31B106KAHNNNE,C_1206_3216Metric,fit,,0.070,0.14,estimate,,,https://www.digikey.com/en/products/result?keywords=CL31B106KAHNNNE,https://www.mouser.com/c/?q=CL31B106KAHNNNE,https://www.lcsc.com/search?q=CL31B106KAHNNNE,
C74,1,4.7nF 2kV,MLCC 4.7nF 2kV X7R 1812,KEMET,C1812C472KGRACTU,C_1812_4532Metric,fit,,0.740,0.74,"DigiKey 2026-11-11, break at 1000",2074,,https://www.digikey.com/en/products/result?keywords=C1812C47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,https://www.mouser.com/c/?q=C1812C472KGRACTU,https://www.lcsc.com/search?q=C1812C472KGRACTU,
C77 C78,2,DNP 50V,MLCC DNP 50V C0G 0402,,,C_0402_1005Metric,DNP,,0.000,0.00,,,,,,,
C98 C99,2,1nF 50V,MLCC 1nF 50V X7R 0402,Samsung,CL05B102KB5NNNC,C_0402_1005Metric,fit,,0.008,0.02,estimate,,,https://www.digikey.com/en/products/result?keywords=CL05B102KB5NNNC,https://www.mouser.com/c/?q=CL05B102KB5NNNC,https://www.lcsc.com/search?q=CL05B102KB5NNNC,
D1,1,SMAJ22A,TVS 22V unidirectional 400W SMA,Littelfuse,SMAJ22A,D_SMA,fit,,0.120,0.12,estimate,,,https://www.digikey.com/en/products/result?keywords=SMAJ22A,https://www.mouser.com/c/?q=SMAJ22A,https://www.lcsc.com/search?q=SMAJ22A,https://www.littelfuse.com/media?resourcetype=datasheets&ite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
D2,1,BZT52C10S 10V,"Zener 10V 200mW SOD-323, Q1 gate clamp",Diodes Inc,BZT52C10S-7-F,D_SOD-323,fit,,0.030,0.03,estimate,,,https://www.digikey.com/en/products/result?keywords=BZT52C10S-7-F,https://www.mouser.com/c/?q=BZT52C10S-7-F,https://www.lcsc.com/search?q=BZT52C10S-7-F,
D3,1,LED red,LED red 0603,Wurth,150060RS75000,LED_0603_1608Metric,fit,,0.030,0.03,estimate,,,https://www.digikey.com/en/products/result?keywords=150060RS75000,https://www.mouser.com/c/?q=150060RS75000,https://www.lcsc.com/search?q=150060RS75000,
D4 D16,2,LED green,LED green 0603,Wurth,150060GS75000,LED_0603_1608Metric,fit,,0.030,0.06,estimate,,,https://www.digikey.com/en/products/result?keywords=150060GS75000,https://www.mouser.com/c/?q=150060GS75000,https://www.lcsc.com/search?q=150060GS75000,
D5,1,LED blue,LED blue 0603,Wurth,150060BS75000,LED_0603_1608Metric,fit,,0.030,0.03,estimate,,,https://www.digikey.com/en/products/result?keywords=150060BS75000,https://www.mouser.com/c/?q=150060BS75000,https://www.lcsc.com/search?q=150060BS75000,
D6 D17,2,LED yellow,LED yellow 0603,Wurth,150060YS75000,LED_0603_1608Metric,fit,,0.030,0.06,estimate,,,https://www.digikey.com/en/products/result?keywords=150060YS75000,https://www.mouser.com/c/?q=150060YS75000,https://www.lcsc.com/search?q=150060YS75000,
D7 D8 D9 D10 D11 D12 D13 D14,8,PMEG10020ELR,"Schottky 100V 2A SOD-123W, PoE input bridge",Nexperia,PMEG10020ELRX,Nexperia_CFP3_SOD-123W,fit,SS210,0.138,1.10,"DigiKey 2026-11-11, break at 500",236366,,https://www.digikey.com/en/products/result?keywords=PMEG10020ELRX,https://www.mouser.com/c/?q=PMEG10020ELRX,https://www.lcsc.com/search?q=PMEG10020ELRX,https://assets.nexperia.com/documents/data-sheet/PMEG10020ELR.pdf
D15,1,SMAJ58A,TVS 58V unidirectional 400W SMA (pin 1 cathode to VPOE_P),Littelfuse,SMAJ58A,D_SMA,fit,,0.120,0.12,estimate,,,https://www.digikey.com/en/products/result?keywords=SMAJ58A,https://www.mouser.com/c/?q=SMAJ58A,https://www.lcsc.com/search?q=SMAJ58A,https://www.littelfuse.com/media?resourcetype=datasheets&ite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
FB1 FB2,2,1k@100MHz 2A,Ferrite bead,Taiyo Yuden,FBMH3225HM102NT,L_1210_3225Metric,fit,,0.530,1.06,"DigiKey 2026-11-11, list price, break not shown",not shown,,https://www.digikey.com/en/products/result?keywords=FBMH3225HM102NT,https://www.mouser.com/c/?q=FBMH3225HM102NT,https://www.lcsc.com/search?q=FBMH3225HM102NT,
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